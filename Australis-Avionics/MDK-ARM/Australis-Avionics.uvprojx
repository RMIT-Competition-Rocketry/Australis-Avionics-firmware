# Keil uVision project Australis-Avionics.uvprojx, settings and files
target Australis-Avionics (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F439IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Australis-Avionics
  group System
    ./System/: startup_stm32f4xx.s startup_stm32f439xx.s stm32f4xx_hal_conf.h stm32f4xx_it.h config.h
    ../MDK-ARM/System/: system_stm32f4xx.c
  group Source
    ../Core/Src/RTOS/: freertos.c
    ../Core/Src/: main.c drivers.c devices.c
    ../Lib/bin/: libavionics.a
  group Shell
    ../Core/Src/shell/: launch.c mem.c baro.c help.c
  group Source/RTOS
    ../Core/Src/RTOS/: freertos.c
    ../Core/Src/RTOS/tasks/: stateUpdate.c
    ../Core/Src/RTOS/tasks/comms/: loraComm.c usbComm.c
    ../Core/Src/RTOS/tasks/data/: flashWrite.c gpsAcquisition.c hDataAcquisition.c lDataAcquisition.c
  group Source/CAN
    ../Core/Src/CAN/: can.c
  group Source/SPI
    ../Core/Src/SPI/: spi.c
    ../Core/Src/SPI/flash/: flash.c
    ../Core/Src/SPI/lora/: lora.c
  group Source/SPI/sensors
    ../Core/Src/SPI/sensors/: sensors.c
    ../Core/Src/SPI/sensors/accel/: KX134_1211.c
    ../Core/Src/SPI/sensors/gyro/: A3G4250D.c
    ../Core/Src/SPI/sensors/baro/: BMP581.c
  group Source/UART
    ../Core/Src/UART/: uart.c
    ../Core/Src/UART/GPS/: gps.c
    ../Core/Src/UART/USB/: shell.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c stream_buffer.c tasks.c timers.c event_groups.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/Tracealyzer
    ../Middlewares/Third_Party/TraceRecorder/: SEGGER_RTT.c trcAssert.c trcCounter.c trcDependency.c trcDiagnostics.c trcEntryTable.c trcError.c trcEvent.c trcEventBuffer.c trcExtension.c trcHardwarePort.c trcHeap.c trcInternalEventBuffer.c trcInterval.c trcISR.c trcKernelPort.c trcMultiCoreEventBuffer.c trcObject.c trcPrint.c trcRunnable.c trcSnapshotRecorder.c trcStackMonitor.c trcStateMachine.c trcStaticBuffer.c trcStreamingRecorder.c trcStreamPort.c trcString.c trcTask.c trcTimestamp.c
  group Data
    ../Data/: accelX.c accelY.c accelZ.c press.c gyroX.c gyroY.c gyroZ.c
